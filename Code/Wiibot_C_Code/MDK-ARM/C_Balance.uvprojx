# Keil uVision project C_Balance.uvprojx, settings and files
target C_Balance (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: C_Balance +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1U,ARM_MATH_CM4,__CC_ARM,__TARGET_FPU_VFP
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Application/Device/IMU;../Application/Support;../Application/Device;../Drivers/CMSIS/DSP/PrivateInclude;../Drivers/CMSIS/DSP/Include;../Application/Driver;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Application/Config;../Application/Module;../Application/Protocol;../Application/Task;../Application/Pack;../Application/Algo
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group CMSIS/DSP
    ../Drivers/CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../Drivers/CMSIS/DSP/Source/CommonTables/: CommonTables.c
    ../Drivers/CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c
    ../Drivers/CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../Drivers/CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group IMU
    ../Application/Device/IMU/: bmi.c BMI088driver.c BMI088Middleware.c
    ../Application/Device/: imu.c imu_pwm.c
  group Drivers
    ../Application/Driver/: drv_haltick.c drv_can.c drv_uart.c
  group Configs
    ../Application/Config/: config_imu.c config_can.c config_mec.h config_uart.c
  group Devices
    ../Application/Device/: dev_all.c remote.c sd_motor.c wheel_motor.c
  group Algorithms
    ../Application/Algo/: lqr.c pid.c
  group Packs
    ../Application/Pack/: ktech_motor.c math_support.c motor.c ave_filter.c dji_pid.c
  group Modules
    ../Application/Module/: my_joint.c my_posture.c my_robot.c my_state_var.c
  group Tasks
    ../Application/Task/: my_task.c
software components: CMSIS:CORE 4.3.0
